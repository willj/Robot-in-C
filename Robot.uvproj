# Keil uVision project Robot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Robot
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s SysTick.c Robot.c Mic.c Motors.c Motors.h
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
    C:/Keil/ARM/INC/TI/TM4C123/: TM4C123GH6PM.h
